options:
  parameters:
    generate_options: no_gui
    id: pluto_si446x
    output_language: python
    run_options: run
  states: {}

blocks:
- name: bt
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 2.5e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 434.000e6
  states: {}
- name: gaussian_taps
  id: variable
  parameters:
    value: firdes.gaussian(1.0,samp_per_sym, bt, 4 * samp_per_sym)
  states: {}
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 12.5e3
    gain: '1.0'
    samp_rate: samp_rate
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '9'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: int(samp_rate / sym_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: tune_offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: tx_taps
  id: variable
  parameters:
    value: numpy.convolve(numpy.array(gaussian_taps),numpy.array((1,) * samp_per_sym))
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2 * math.pi * deviation / samp_rate
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate / (2 * math.pi * deviation)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: tune_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_rate / sym_rate * (1+0.0)
    omega_relative_limit: '0.000200'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune_offset
    decim: '1'
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '2000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: int((freq - tune_offset) * (1 + ppm / 1e6))
    samplerate: int(samp_rate)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int((freq-tune_offset) * (1 + ppm / 1e6))
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: samp_per_sym
    taps: tx_taps
    type: fff
  states: {}
- name: si446x_var_len_packet_handler_0
  id: si446x_var_len_packet_handler
  parameters:
    check_crc: 'True'
    crc_poly: '0x1021'
    has_crc: 'True'
    sync: '0x2DD4'
  states: {}
- name: var_len_packet_creator_0
  id: var_len_packet_creator
  parameters:
    crc_poly: '0x1021'
    has_crc: 'True'
    preamble_bytes: '8'
    sync: '0x2DD4'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:52000
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:52001
    timeout: '100'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_multiply_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [digital_binary_slicer_fb_0, '0', si446x_var_len_packet_handler_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [si446x_var_len_packet_handler_0, out, zeromq_pub_msg_sink_0, in]
- [var_len_packet_creator_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zeromq_sub_msg_source_0, out, var_len_packet_creator_0, in]

metadata:
  file_format: 1
